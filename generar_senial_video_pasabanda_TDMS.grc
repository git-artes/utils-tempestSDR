<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>30e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>cutoff</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2e6</value></param>
<param><key>step</key><value>500e3</value></param>
<param><key>stop</key><value>px_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>inter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>epsilon</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.99</value></param>
<param><key>step</key><value>10e-6</value></param>
<param><key>stop</key><value>1.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filtro_ecualizador</value></param>
<param><key>value</key><value>[  3.5209e-07 - 1.0836e-06*1j,  1.4076e-06 - 2.3919e-06*1j,  5.9650e-06 - 6.1506e-06*1j,  1.5271e-05 - 1.4326e-05*1j,  4.1151e-05 - 3.6713e-05*1j , 3.9905e-04 - 6.3391e-04*1j,  1.4256e-03 - 4.2010e-04*1j,  1.7775e-03 - 1.1448e-03*1j,  2.6252e-03 - 8.9501e-04*1j,  2.9812e-03 - 1.6801e-03*1j , 4.3656e-03 - 1.5903e-03*1j,  4.8418e-03 - 2.4404e-03*1j,  6.9685e-03 - 2.6534e-03*1j,  7.6915e-03 - 3.5182e-03*1j,  1.0749e-02 - 4.2291e-03*1j , 1.1902e-02 - 5.0055e-03*1j,  1.6024e-02 - 6.4526e-03*1j,  1.7878e-02 - 7.0057e-03*1j,  2.3102e-02 - 9.4388e-03*1j,  2.6038e-02 - 9.6422e-03*1j , 3.2280e-02 - 1.3269e-02*1j,  3.6789e-02 - 1.3061e-02*1j,  4.3841e-02 - 1.7982e-02*1j,  5.0495e-02 - 1.7431e-02*1j,  5.8052e-02 - 2.3569e-02*1j , 6.7444e-02 - 2.2930e-02*1j,  7.5169e-02 - 2.9981e-02*1j,  8.7819e-02 - 2.9736e-02*1j,  9.5427e-02 - 3.7136e-02*1j,  1.1167e-01 - 3.8000e-02*1j , 1.1904e-01 - 4.4941e-02*1j,  1.3890e-01 - 4.7822e-02*1j,  1.4617e-01 - 5.3309e-02*1j,  1.6926e-01 - 5.9221e-02*1j,  1.7695e-01 - 6.2182e-02*1j , 2.0235e-01 - 7.2116e-02*1j,  2.1140e-01 - 7.1549e-02*1j,  2.3765e-01 - 8.6305e-02*1j,  2.4944e-01 - 8.1456e-02*1j,  2.7453e-01 - 1.0146e-01*1j , 2.9088e-01 - 9.2017e-02*1j,  3.1227e-01 - 1.1711e-01*1j,  3.3535e-01 - 1.0341e-01*1j,  3.5009e-01 - 1.3267e-01*1j,  3.8238e-01 - 1.1587e-01*1j , 3.8713e-01 - 1.4742e-01*1j,  4.3146e-01 - 1.2974e-01*1j,  4.2233e-01 - 1.6044e-01*1j,  4.8222e-01 - 1.4561e-01*1j,  4.5414e-01 - 1.7040e-01*1j , 5.3510e-01 - 1.6460e-01*1j,  4.8020e-01 - 1.7358e-01*1j,  5.9455e-01 - 1.9170e-01*1j,  4.8669e-01 - 1.5965e-01*1j,  6.9081e-01 - 2.6218e-01*1j , 3.1530e-01 + 9.3424e-02*1j, -7.1052e-01 + 2.8833e-01*1j, -5.1861e-01 + 1.1433e-01*1j, -5.7535e-01 + 2.2141e-01*1j, -5.2124e-01 + 1.3015e-01*1j , -5.1574e-01 + 1.9092e-01*1j, -4.9507e-01 + 1.3022e-01*1j, -4.6700e-01 + 1.6704e-01*1j, -4.5921e-01 + 1.2586e-01*1j, -4.2136e-01 + 1.4550e-01*1j , -4.1873e-01 + 1.1899e-01*1j, -3.7785e-01 + 1.2562e-01*1j, -3.7593e-01 + 1.1045e-01*1j, -3.3620e-01 + 1.0737e-01*1j, -3.3244e-01 + 1.0068e-01*1j , -2.9648e-01 + 9.0865e-02*1j, -2.8954e-01 + 9.0026e-02*1j, -2.5879e-01 + 7.6211e-02*1j, -2.4833e-01 + 7.8847e-02*1j, -2.2331e-01 + 6.3414e-02*1j , -2.0968e-01 + 6.7517e-02*1j, -1.9019e-01 + 5.2395e-02*1j, -1.7425e-01 + 5.6423e-02*1j, -1.5960e-01 + 4.2999e-02*1j, -1.4246e-01 + 4.5930e-02*1j , -1.3169e-01 + 3.5031e-02*1j, -1.1454e-01 + 3.6352e-02*1j, -1.0661e-01 + 2.8282e-02*1j, -9.0505e-02 + 2.7922e-02*1j, -8.4485e-02 + 2.2562e-02*1j , -7.0222e-02 + 2.0778e-02*1j, -6.5365e-02 + 1.7714e-02*1j, -5.3441e-02 + 1.4956e-02*1j, -4.9242e-02 + 1.3619e-02*1j, -3.9832e-02 + 1.0400e-02*1j , -3.6019e-02 + 1.0195e-02*1j, -2.9025e-02 + 6.9842e-03*1j, -2.5513e-02 + 7.3869e-03*1j, -2.0639e-02 + 4.5335e-03*1j, -1.7457e-02 + 5.1469e-03*1j , -1.4300e-02 + 2.8536e-03*1j, -1.1520e-02 + 3.4260e-03*1j, -9.6508e-03 + 1.7541e-03*1j, -7.3304e-03 + 2.1628e-03*1j, -6.3552e-03 + 1.0661e-03*1j , -4.5025e-03 + 1.2798e-03*1j, -4.1002e-03 + 6.5174e-04*1j, -2.6663e-03 + 6.8397e-04*1j, -2.5965e-03 + 4.0387e-04*1j, -1.4935e-03 + 2.7171e-04*1j , -1.6079e-03 + 2.1239e-04*1j,  8.5832e-05 + 6.1758e-05*1j,  2.4841e-05 + 1.8521e-05*1j,  9.8862e-06 + 7.4457e-06*1j,  3.4696e-06 + 2.6799e-06*1j , 7.2346e-07 + 6.5333e-07*1j ]</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>filtro_o_no</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>no filtrar</value></param>
<param><key>label1</key><value>filtrar</value></param>
<param><key>label</key><value>filtrar o no?</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frec</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>error_frec</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-px_rate</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>px_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frec_central</value></param>
<param><key>value</key><value>px_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Center freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>px_rate</value></param>
<param><key>stop</key><value>samp_rate/2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mag_o_real</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>magnitud</value></param>
<param><key>label1</key><value>real</value></param>
<param><key>label</key><value>mag o real?</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulso_rectangular</value></param>
<param><key>value</key><value>[1]*inter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>px_rate</value></param>
<param><key>value</key><value>1024*624*60/2*10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ruido</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>px_rate*inter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>int(40e6)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>px_rate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>px_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>comment</key><value>elijo entre módulo (AM)
o no</value></param>
<param><key>input_index</key><value>mag_o_real</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>comment</key><value>elijo entre ecualizado 
y no ecualizado</value></param>
<param><key>input_index</key><value>filtro_o_no</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/home/pablo2/salida_fifo.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/pablo2/Link to Maestría/Octave/imagen_TDMS_red800600.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>comment</key><value>lo paso por el canal</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>frec/samp_rate</value></param>
<param><key>noise_voltage</key><value>0.01</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>comment</key><value>genero la forma de onda en el cable</value></param>
<param><key>interp</key><value>inter</value></param>
<param><key>taps</key><value>pulso_rectangular</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>filtro_ecualizador</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>150e6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>4e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>lo pongo a la tasa que tenga el USRP</value></param>
<param><key>decim</key><value>px_rate</value></param>
<param><key>interp</key><value>usrp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>comment</key><value>lo devuelvo a tasa de pixel</value></param>
<param><key>decim</key><value>inter</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>solo_interpolating</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>solo_interpolating</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>interp_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
